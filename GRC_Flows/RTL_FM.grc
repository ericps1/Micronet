<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable_slider</key>
<param><key>id</key><value>audio_gain</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>10</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,2,1,24</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>11</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>decim*256e3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>WBFM_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>105.3e6</value></param>
<param><key>min</key><value>88.1e6</value></param>
<param><key>max</key><value>108.1e6</value></param>
<param><key>num_steps</key><value>181</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,2,1,24</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>RF_gain</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>40</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>45</value></param>
<param><key>num_steps</key><value>46</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,26,1,24</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>notebook_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['FFT Plot','Waterfall Plot']</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>mode</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>['WBFM','NBFM']</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_VERTICAL</value></param>
<param><key>grid_pos</key><value>0,0,1,2</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value>'rtl=0'</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>105.3e6</value></param>
<param><key>gain_mode0</key><value>0</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>quad_rate</key><value>256e3</value></param>
<param><key>audio_decimation</key><value>8</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0_0</value></param>
<param><key>samp_rate</key><value>32000</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>FM_Radio</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>rational_resampler_base_xxx</key>
<param><key>id</key><value>rational_resampler_base_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>1</value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>rational_resampler_base_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_base_xxx_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>audio_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
